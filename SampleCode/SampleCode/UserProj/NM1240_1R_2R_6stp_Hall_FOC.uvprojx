# Keil uVision project NM1240_1R_2R_6stp_Hall_FOC.uvprojx, settings and files
target NM1230_1R_2R_6stp_Hall_FOC (6240000::V6.24::ARMCLANG)
  device: NM1244D48 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NM1240_1R_2R_6stp_Hall_FOC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\NM1240\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NM1240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    C:/Users/JPChang0/Desktop/nuvoTon/!Project-NuMotor Solution/!Development of NM1244/[Example Code] NuMotor NM1240_Rev4.1_20250806/SW/Library/StdDriver/src/: usci_uart.c
    C:/Users/JPChang0/Desktop/nuvoTon/!Project-NuMotor Solution/!Development of NM1244/[Example Code] NuMotor NM1240_Rev4.1_20250806/SW/Library/Device/Nuvoton/NM1240/Source/: system_NM1240.c
    C:/Users/JPChang0/Desktop/nuvoTon/!Project-NuMotor Solution/!Development of NM1244/[Example Code] NuMotor NM1240_Rev4.1_20250806/SW/Library/Device/Nuvoton/NM1240/Source/ARM/: startup_NM1240.s
  group Library
    C:/Users/JPChang0/Desktop/nuvoTon/!Project-NuMotor Solution/!Development of NM1244/[Example Code] NuMotor NM1240_Rev4.1_20250806/SW/Library/StdDriver/src/: sys.c clk.c gpio.c adc.c fmc.c
  group User
    ./program/: main.c INT_ISR.C motor_FOC.c motor_funtions.c motor_six_step.c PI_control.c protocol.c system_initialize.C variable_initialize.c svpwm_v02.lib
software components: CMSIS:CORE 6.1.1
