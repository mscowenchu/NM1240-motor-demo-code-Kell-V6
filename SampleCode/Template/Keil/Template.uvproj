# Keil uVision project Template.uvproj, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NM1234D Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NM1230\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NM1230.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NM1230/Source/: system_NM1230.c
    ../../../Library/Device/Nuvoton/NM1230/Source/ARM/: startup_NM1230.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c sys.c clk.c usci_uart.c
  group User
    ../: main.c
